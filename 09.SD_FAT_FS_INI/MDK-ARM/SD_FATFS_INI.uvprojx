# Keil uVision project SD_FATFS_INI.uvprojx, settings and files
target SD_FATFS_INI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SD_FATFS_INI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\ini_parse;..\MultiButton
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c gpio.c bsp_driver_sd.c sd_diskio.c fatfs.c sdmmc.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group ini_parse
    ../ini_parse/: dictionary.c iniparser.c
  group Button_Driver
    ../MultiButton/: multi_button.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
software components: CMSIS:CORE 4.3.0
